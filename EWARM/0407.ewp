# IAR project 0407.ewp, settings and files
configuration 0407 (ARM, debug)
  General.OGChipSelectEditMenu: FM33FH05X FMSH FM33FH05X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: FM33FH0XX
  ICCARM.CCIncludePath2: ../TSI/Tuner; ../TSI/Library; ../Users; ../Drivers/FM33FH0xx_FL_Driver/Inc; ../TSI/Tuner/Interfaces; ../Drivers/CMSIS/Device/FM/FM33xx/Include; ../TSI/Users
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 0407.hex
  ILINK.IlinkOutputFile: 0407.out
  ILINK.IlinkIcfFile: ../0407.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33fh0xx.s
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fh0xx.c
  group Drivers/FM33FH0xx_FL_Driver
    ../Drivers/FM33FH0xx_FL_Driver/Src/: fm33fh0xx_fl.c fm33fh0xx_fl_adc.c fm33fh0xx_fl_atim.c fm33fh0xx_fl_bstim16.c fm33fh0xx_fl_canfd.c fm33fh0xx_fl_cmu.c fm33fh0xx_fl_comp.c fm33fh0xx_fl_crc.c fm33fh0xx_fl_dac.c fm33fh0xx_fl_dma.c fm33fh0xx_fl_exti.c fm33fh0xx_fl_flash.c fm33fh0xx_fl_gpio.c fm33fh0xx_fl_i2c.c fm33fh0xx_fl_iwdt.c fm33fh0xx_fl_lptim16.c fm33fh0xx_fl_lpuart.c fm33fh0xx_fl_pmu.c fm33fh0xx_fl_qspi.c fm33fh0xx_fl_rtc.c fm33fh0xx_fl_sent.c fm33fh0xx_fl_spi.c fm33fh0xx_fl_svd.c fm33fh0xx_fl_tau.c fm33fh0xx_fl_uart.c fm33fh0xx_fl_wwdt.c
  group TSI/Library
    ../TSI/Library/Devices/: fm33fh0xx_tsi_driver.c
    ../TSI/Library/: tsi.c tsi_calibration.c tsi_driver.c tsi_filter.c tsi_plugin.c tsi_processing.c tsi_utils.c
  group TSI/Plugins
    ../TSI/Library/Plugins/: tsi_plugin_commnoise.c tsi_plugin_sc_margin_calibration.c tsi_plugin_widget_timeout.c
  group TSI/Tuner
    ../TSI/Tuner/: bdp.c
    ../TSI/Tuner/Interfaces/: bdp_mem_interface.c
  group TSI/Users
    ../TSI/Users/: bdp_user.c tsi_object.c
  group Users
    ../Users/: led.c main.c svd.c timer.c tmp.c Uart.c
